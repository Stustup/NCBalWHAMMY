File: InOut.kicad_sch (KiCad schematic)
At the start: 12 parts

Commit message: optimization
Other:
- moved on the sheet: C?, D?, K?, R?, SW?, TP?
